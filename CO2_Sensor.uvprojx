# Keil uVision project CO2_Sensor.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AC78013MDQA AutoChips
  pack: AutoChips.AC780x_DFP.1.0.3
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CO2_Sensor
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\soure\headers;C:\Program Files\Keil_v5\ARM\Pack\AutoChips\AC780x_DFP\1.0.3\ATC_Driver\inc;C:\Program Files\Keil_v5\ARM\Pack\AutoChips\AC780x_DFP\1.0.3\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MCU
    ./soure/MCU/: TEMCU_ADC.c TEMCU_DMA.c TEMCU_Flash.c TEMCU_IOInit_AC7801x_LQFP48.c TEMCU_NVIC.c TEMCU_Timer.c TEMCU_Uart.c
  group SYS
    ./soure/Sys/: TESW_EEPROM.c TEEvent.c
  group Main
    ./soure/: main.c
    ./soure/headers/: main.h TEMacro.h
  group headers
    ./soure/headers/: TECom_Cache.h main.h TEEvent.h TEMacro.h TEMCU.h TEMCU_ADC.h TEMCU_CLK.h TEMCU_DMA.h TEMCU_Flash.h TEMCU_IO.h TEMCU_NVIC.h TEMCU_Timer.h TEMCU_Uart.h TESW_EEPROM.h TECom.h TETypes.h TECrc16_modbus.h
  group com
    ./soure/CO2/com/: TECom.c TECrc16_modbus.c TECom_Cache.c
software components: CMSIS:CORE 5.0.2, Device:ATC Drivers:ADC 1.0.0, Device:ATC Drivers:CKGEN 1.0.0, Device:ATC Drivers:DMA 1.0.0, Device:ATC Drivers:GPIO 1.0.0, Device:ATC Drivers:SPM 1.0.0, Device:ATC Drivers:TIMER 1.0.0, Device:ATC Drivers:UART 1.0.0, Device:ATC Drivers:WDG 1.0.0, Device:ATC Drivers:eFlash 1.0.0, Device:Startup 1.0.0
